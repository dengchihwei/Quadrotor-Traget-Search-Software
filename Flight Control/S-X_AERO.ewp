# IAR project S-X_AERO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewam; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCIncludePath2: $PROJ_DIR$; app; board; chip; app\openpilot; app\openpilot\Data; app\openpilot\math; app\openpilot\Param; driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S-X_AERO.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ewam; PART_TM4C123GH6PM; TARGET_IS_BLIZZARD_RB1
  ICCARM.CCIncludePath2: G:\ti\TivaWare_C_Series-1.0; app; board; chip; app\openpilot; app\openpilot\Data; app\openpilot\math; app\openpilot\Param
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: c.srec
  group App
    app/: IRQ_handler.c main.c
    app/openpilot/: virtualflybar.c
  group App/OpenPilot
    app/openpilot/: attitudesolving.c control_command.c data_common.c data_transfer.c hold.c mixer.c motor_control.c param_common.c Postion_Hold.c relay_tuning.c sensorfetch.c stabilization.c
    app/openpilot/Param/: eepromqsj.c
  group App/OpenPilot/Data
    app/openpilot/Data/: acceldesired.c accels.c accessorydesired.c actuatorcommand.c actuatordesired.c attitudeactual.c attitudesensor.c flightbatterystate.c flightstatus.c gyros.c gyrosbias.c manualcontrolcommand.c mixerstatus.c nrf_data.c ratedesired.c relaytuning.c stabilizationdesired.c state_struct.c timestamp.c trimangles.c uart_data.c
  group App/OpenPilot/Math
    app/openpilot/math/: atmospheric_math.c coordinate_conversions.c misc_math.c pid.c sin_lookup.c
  group App/OpenPilot/Param
    app/openpilot/Param/: actuatorsettings.c attitudesettings.c manualcontrolsettings.c mixersettings.c motorsettings.c relaytuningsettings.c sensorsettings.c stabilizationsettings.c systemsettings.c
  group Board
    board/: KS103.c PX4Flow.c uartstdio.c YRK_AK8975_SOFT.c YRK_init.c YRK_LED.c YRK_MPU6050_SOFT.c YRK_NRF24L0.c YRK_SONAR.c
  group Chip
    chip/: common.c
  group Lib
    lib/: driverlib.a startup_ewarm.c
