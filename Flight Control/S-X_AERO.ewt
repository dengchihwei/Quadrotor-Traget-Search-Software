<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <group>
      <name>OpenPilot</name>
      <group>
        <name>Data</name>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\acceldesired.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\accels.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\accessorydesired.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\actuatorcommand.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\actuatordesired.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\attitudeactual.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\attitudesensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\flightbatterystate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\flightstatus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\gyros.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\gyrosbias.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\manualcontrolcommand.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\mixerstatus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\nrf_data.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\ratedesired.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\relaytuning.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\stabilizationdesired.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\state_struct.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\timestamp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\trimangles.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Data\uart_data.c</name>
        </file>
      </group>
      <group>
        <name>Math</name>
        <file>
          <name>$PROJ_DIR$\app\openpilot\math\atmospheric_math.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\math\coordinate_conversions.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\math\misc_math.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\math\pid.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\math\sin_lookup.c</name>
        </file>
      </group>
      <group>
        <name>Param</name>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\actuatorsettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\attitudesettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\manualcontrolsettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\mixersettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\motorsettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\relaytuningsettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\sensorsettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\stabilizationsettings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app\openpilot\Param\systemsettings.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\app\openpilot\attitudesolving.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\control_command.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\data_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\data_transfer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\Param\eepromqsj.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\hold.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\mixer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\motor_control.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\param_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\Postion_Hold.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\relay_tuning.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\sensorfetch.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app\openpilot\stabilization.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\app\IRQ_handler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\openpilot\virtualflybar.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\board\KS103.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\PX4Flow.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\uartstdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\YRK_AK8975_SOFT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\YRK_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\YRK_LED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\YRK_MPU6050_SOFT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\YRK_NRF24L0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\YRK_SONAR.c</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\chip\common.c</name>
    </file>
  </group>
  <group>
    <name>Lib</name>
    <file>
      <name>$PROJ_DIR$\lib\driverlib.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lib\startup_ewarm.c</name>
    </file>
  </group>
</project>


